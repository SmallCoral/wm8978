# Repository SmallCoral/wm8978

File README.md:

# WM8978 USB 声卡

基于 **ATSAMD21E18A** 和 **WM8978** 的 USB 音频硬件项目，目标支持 **48 kHz / 16-bit 全双工音频**，提供耳机播放、麦克风采集和扬声器输出。

## 硬件特点

- USB-C 供电与通信，包含 ESD 保护、限流和 3.3 V 稳压。
- SAMD21 与 WM8978 通过 I²S 传输音频，通过 I²C 配置 codec。
- 独立的 12 MHz 主控时钟与 12.288 MHz 音频时钟。
- 立体声耳机输出、驻极体麦克风输入、BTL 扬声器输出及 SWD 调试接口。
- 提供 KiCad 原理图、PCB、自定义库和项目 3D 模型。

## 打开工程

安装 **KiCad 10** 及其标准符号、封装和 3D 模型库，然后打开 [WM8978.kicad_pro](pcb/WM8978.kicad_pro)。项目自定义库与模型使用相对路径。

## 目录

| 目录 | 内容 |
| --- | --- |
| [pcb/](pcb/) | KiCad 工程、原理图、PCB 与器件库 |
| [scripts/](scripts/) | 原理图检查、PCB 同步与模型处理脚本 |
| [reports/](reports/) | 设计复核记录与导出资料 |

## 项目状态

目前处于硬件验证阶段，USB 音频固件与实板测试尚未完成。

[原理图预览](reports/project-snapshot/2026-09-23/WM8978.pdf) · [设计检查记录](reports/footprint-binding/2026-10-03/review.md) · [3D 模型说明](pcb/WM8978.3dshapes/README.md)

## KiCad design pcb/WM8978.kicad_pcb

File pcb/README.md:

# WM8978 USB 声卡硬件说明

主原理图为 `WM8978.kicad_sch`，功能已按信号流拆成 4 个子页：

- `01_usb_power.kicad_sch`：USB Type-C、CC 下拉、USB ESD/串联电阻和 3.3 V 电源
- `02_stm32.kicad_sch`：STM32F407、8 MHz HSE、复位、BOOT0、SWD 和 MCU 去耦
- `03_wm8978.kicad_sch`：WM8978、两线控制接口、I2S、VMID 和 codec 去耦
- `04_audio_output.kicad_sch`：3.5 mm 耳机输出和 BTL 扬声器接口

## 当前功能链路

- USB-C A6/B6（D+）经 D1、R53 接 STM32 PA12。
- USB-C A7/B7（D-）经 D2、R54 接 STM32 PA11。
- CC1、CC2 分别用 5.1 kΩ 下拉，接口工作在 USB 设备/UFP 模式。
- STM32 I2S2 使用 PC6/MCLK、PB13/BCLK、PB12/LRCLK、PC3/DACDAT。
- WM8978 控制接口使用 PD6/SCLK、PD7/SDIN，CSB 接地，MODE 用 10 kΩ 下拉，
  因而采用两线控制模式。
- WM8978 ROUT1/LOUT1 经 220 µF 隔直后接 3.5 mm 耳机座。
- ROUT2/LOUT2 作为 BTL 差分扬声器输出；SPK_P、SPK_N 都不能接地。

## 与旧版单页原理图相比

保留了 USB 播放、耳机输出、WM8978 内置扬声器驱动、SWD 和复位功能；删除了
麦克风/模拟采集、LSE、外置 24.576 MHz 音频振荡器、EEPROM、状态 LED、启动
选择开关和 TDA2822 外置功放。新版本由 STM32 作为 I2S 时钟主机，旧版固件中
“WM8978 + 24.576 MHz 振荡器作为时钟主机”的初始化逻辑不能直接沿用。

## 供电与器件约束

- USB VBUS 直接给 WM8978 SPKVDD，3.3 V 给 STM32 和 WM8978 的 AVDD/DCVDD/DBVDD。
- 3.3 V 稳压器指定为与 AMS1117 引脚兼容的 `TLV1117LV33DCYR`，可稳定驱动现有
  陶瓷输入/输出电容；不要在不核对输出电容 ESR 要求的情况下换回泛化 AMS1117。
- C83（VMID）使用 4.7 µF/0805；C77、C78、C89、C93 使用 10 µF/0805。
- C88、C90、C91 分别作为 WM8978 三个 3.3 V 电源脚的 100 nF 就地去耦，C89
  提供 codec 本地 10 µF 储能；C92/C93 给 SPKVDD 去耦。
- C86、C87 为 220 µF/6.3 V 贴片电解，正极朝向 WM8978 输出端。
- X3 为 8 MHz、CL=12 pF 晶体，C68/C69 为 18 pF；正式选定料号后仍需按实际
  杂散电容复核负载电容。

## PCB 实现要点

- D1/D2 紧贴 USB-C；R53/R54 靠近 STM32 PA12/PA11。
- 晶体、C68、C69 紧贴 MCU，且晶振回路下方不要走高速信号。
- 每个 100 nF 去耦必须紧贴对应电源脚，先到电容再到电源面，并使用短地过孔。
- WM8978 模拟输出远离 USB 和 I2S 时钟；耳机回流不要穿过 USB/MCU 数字回流区。
- SPK_P/SPK_N 按差分对成组走线，不允许任一路接地。
- USB 供电下扬声器满功率会显著增加 VBUS 电流，固件应限制初始音量并软启动。

## 校验结果

使用 KiCad 10.0.6 对层次原理图执行完整 ERC，错误和警告均为 0；同时导出网表
核对了 USB、I2S、控制总线、耳机和 BTL 扬声器的端到端连接。ERC 不能代替实物
验证，首板仍应依次检查 5 V、3.3 V、HSE、MCLK/BCLK/LRCLK、USB 枚举和静音
状态下的输出直流电压。

Parts:
C75, C76, C88, C90, C92, C97, C99, C102, C104, C106: 100nF; C_0603_1608Metric; Voltage 16V
C77, C83, C89, C91, C93, C96, C107: 4.7uF; C_0603_1608Metric; Voltage 16V
C78: 10uF; C_0603_1608Metric; Voltage 16V
C79, C80, C105: 1uF; C_0603_1608Metric; Voltage 16V
C86, C87: 470uF/16V; CP_Elec_8x10.5; MPN EEEFK1C471P
C98, C100: 10uF / 16V; C_0603_1608Metric; Voltage 16V
C101: 1uF / 16V; C_0603_1608Metric; Voltage 16V
C103: 10nF; C_0603_1608Metric; Voltage 16V
CN2: HEADPHONE 3.5mm; AUDIO-TH_PJ-3136-B; MPN PJ-3136-B
D1, D2: PESD5V0U1BA; D_SOD-323
J2: JLINK SWD; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical; MPN B4B-XH-A(LF)(SN)
MIC1: ELECTRET MIC; MIC-TH_BD4.0-P1.40-D0.4-L-FD
R53, R54: 22R; R_0603_1608Metric
R63, R64: 4.7k; R_0603_1608Metric
R65, R66: 5.1k; R_0603_1608Metric
R68: 2.2k; R_0603_1608Metric
R70: 10k; R_0603_1608Metric
R71: 1k; R_0603_1608Metric
R73: 33R; R_0603_1608Metric
R74: 100k; R_0603_1608Metric
R75, R76: 33R; R_0603_1608Metric; Tolerance 1%
R78: 61.9k; R_0603_1608Metric; Tolerance 1%
SPK2: SPEAKER 8R BTL; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
U1: ATSAMD21E18A-A; TQFP-32_7x7mm_P0.8mm; MPN ATSAMD21E18A-AU
U15: TLV1117LV33DCYR; SOT-223; MPN TLV1117LV33DCYR
U16: WM8978CGEFL/RV; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm; MPN WM8978CGEFL/RV
U17: TPS2553DBVR; SOT-23-6; MPN TPS2553DBVR
USB2: USB-C USB2 DEVICE; USB_C_GCT_USB4105_GF_A; MPN USB4105-GF-A
Y1: 12MHz / 3.3V / 50ppm; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ASE-12.000MHZ-LC-T
Y2: 12.288MHz / 3.3V / 50ppm; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ASE-12.288MHZ-L-C-T

Connections:
+3V3: C76.1, C78.1, C88.1, C89.1, C90.1, C91.1, C97.1, C98.1, C99.1, C100.1, C103.1, C104.1, C106.1, C107.1, J2.1, R63.2, R64.2, R70.1, R71.1, U1.9 (VDDANA), U1.30 (VDDIN), U15.2 (VOUT), U15.4 (TAB), U16.13 (DCVDD), U16.14 (DBVDD), U16.31 (AVDD), Y1.4 (Vdd), Y2.4 (Vdd)
/AUDIO_CLK_EN: R74.1, U1.19 (PA18_/_XO_EN), Y1.1 (EN), Y2.1 (EN)
/AUDIO_MCLK: R73.2, U16.11 (MCLK)
/AUDIO_OSC: R73.1, Y2.3 (OUT)
/CODEC_BCLK: R75.1, U16.8 (BCLK)
/CODEC_LRCLK: R76.1, U16.7 (LRC)
/CODEC_SCL: R64.1, U1.22 (PA23_/_SCL), U16.16 (SCLK)
/CODEC_SDA: R63.1, U1.21 (PA22_/_SDA), U16.17 (SDIN)
/I2S_ADCDAT: U1.11 (PA08_/_I2S_RX), U16.9 (ADCDAT)
/I2S_BCLK: R75.2, U1.13 (PA10_/_SCK0)
/I2S_DACDAT: U1.8 (PA07_/_I2S_TX), U16.10 (DACDAT)
/I2S_LRCLK: R76.2, U1.14 (PA11_/_FS0)
/MCU_12M: U1.15 (PA14_/_XIN), Y1.3 (OUT)
/MCU_RESET_N: C102.1, R70.2, U1.26 (~RESET)
/MICBIAS: C96.1, R68.1, U16.32 (MICBIAS)
/MIC_LIN: C80.1, U16.2 (LIN)
/MIC_LIP: C79.1, U16.1 (LIP)
/SWCLK: J2.3, R71.2, U1.31 (PA30_/_SWCLK)
/SWDIO: J2.2, U1.32 (PA31_/_SWDIO)
/USB_DM: R54.2, U1.23 (PA24_/_USB_DM)
/USB_DP: R53.2, U1.24 (PA25_/_USB_DP)
/VBUS_5V: C75.1, C77.1, C92.2, C93.2, U15.3 (VIN), U16.26 (SPKVDD), U17.6 (OUT)
/VBUS_RAW: C105.1, U17.1 (IN), U17.3 (EN), USB2.A4 (VBUS), USB2.A9 (VBUS), USB2.B4 (VBUS), USB2.B9 (VBUS)
/VDDCORE: C101.1, U1.29 (VDDCORE)
GND: C75.2, C76.2, C77.2, C78.2, C80.2, C83.2, C88.2, C89.2, C90.2, C91.2, C92.1, C93.1, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, CN2.2, D1.2 (A2), D2.2 (A2), J2.4, MIC1.2, R65.2, R66.2, R74.2, R78.2, U1.10 (GND), U1.28 (GND), U15.1 (GND), U16.12 (DGND), U16.15 (CSB/GPIO1), U16.18 (MODE), U16.24 (SPKGND), U16.28 (AGND), U16.33 (EPAD), U17.2 (GND), USB2.1 (GND_/_SHIELD), USB2.2 (GND_/_SHIELD), USB2.3 (GND_/_SHIELD), USB2.4 (GND_/_SHIELD), USB2.A1 (GND_/_SHIELD), USB2.A12 (GND_/_SHIELD), USB2.B1 (GND_/_SHIELD), USB2.B12 (GND_/_SHIELD), Y1.2 (GND), Y2.2 (GND)
unnamed: C79.2, MIC1.1, R68.2
unnamed: C86.2, CN2.3
unnamed: C87.2, CN2.4
unnamed: D1.1 (A1), R53.1, USB2.A6 (D+), USB2.B6 (D+)
unnamed: D2.1 (A1), R54.1, USB2.A7 (D-), USB2.B7 (D-)
unnamed: C87.1, U16.30 (LOUT1)
unnamed: SPK2.2, U16.25 (LOUT2)
unnamed: C86.1, U16.29 (ROUT1)
unnamed: SPK2.1, U16.23 (ROUT2)
unnamed: C83.1, U16.27 (VMID)
unnamed: R78.1, U17.5 (ILIM)
unnamed: R65.1, USB2.A5 (CC1)
unnamed: R66.1, USB2.B5 (CC2)

Notes on the sheet:
固件：核对 SAMD21 硅版本（C/D/H），遵循 DS80000760 勘误。 USB 异步音频需反馈及 DMA 缓冲；本工程未提供固件。 USB 配置完成前关闭扬声器；整机持续电流不超过 350 mA， 并满足 USB 主机供电预算；挂起电流需实板验证。
USB 输入：R78 = 61.9 kΩ / 1%，限流约 425 mA。 C105 = 1 µF，直接接 VBUS；输出电容位于软启动开关之后。
编解码器使用 Y2 的 12.288 MHz MCLK，关闭 PLL；SYSCLK=256fs。 R6：CLKSEL=MCLK，MCLKDIV=/1，BCLKDIV=/4，MS=1。 LRCLK 为 48 kHz，BCLK 为 3.072 MHz；32 位时隙 / 16 位采样。 SAMD21 的 I2S 时钟单元 0 设为从机；R75/R76 靠近编解码器输出端。
C86/C87：松下 EEEFK1C471P，470 µF / 16 V。 罐体直径 8 mm；正极朝向音频编解码器。 SPK2 为 BTL 桥接输出，两端均不可接地。
布局：C106/C107 靠近 AVDD；AVDD 直接接 3.3 V。 使用连续完整的地平面；时钟和 USB 走线远离麦克风输入， 耳机回流路径避开麦克风电路。
使用 OSC8M 启动 → PA18 拉高 → 等待至少 2 ms → 切换至 12 MHz XOSC 外部时钟。 Y1 为单片机及 USB 提供时钟；Y2 的 12.288 MHz 仅供编解码器，编解码器为 I2S 主机。 USB 与音频时钟异步，需使用反馈及 DMA 缓冲。 挂起前：先静音，将单片机切回内部时钟，再关闭 Y1/Y2。
J2 引脚：1=VTref，2=SWDIO，3=SWCLK，4=GND。 四线 SWD 接口，未引出外部复位；必要时断电重启。
信号采用连续导线连接，标签仅作标注；电源和地使用常规符号。
SAMD21E18A + WM8978 | USB 全双工音频 | 48 kHz / 16 位

Board: 2 copper layers, 39.5 x 74.8 mm, 54 parts (0 on the bottom side), 38 nets.
